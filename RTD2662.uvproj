# Keil uVision project RTD2662.uvproj, settings and files
target RTD2662 (MCS-51)
  device: W79E632 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0-0xFFFF)  XRAM(0-0x3FF) CLOCK(40000000)MODDP2
  output: RTD2662 +hex
  AfterMake: Merge128K.bat
  c flags: Optimize=9 SizeSpeed=1
  group Code_B0
    ./Core/code/mcu/: Timer.c Uart.c
    ./Core/code/: Auto.c FrameSync.c Main.c Mode.c Struct.c Sync.c Adjust.c Adjust_customer.c
    ./Core/code/ext_device/: video.c eeprom.c
    ./Core/code/rtd2662/: YPbPr.c Power.c Scaler.c Source.c Misc.c Hdmi.C
  group Header
    ./Core/header/: YPbPr.h Auto.h Ddc.h Eeprom.h EepromDefault.h EepromDefaultCustomer.h FrameSync.h Global.h I2c.h Include.h Main.h MainDef.h Mcu.h Misc.h Mode.h ModeTable.h Power.h RTDAccess.h Scaler.h ScalerDef.h Struct.h Sync.h SystemTable.h Timer.h Uart.h Video.h Adjust.h Adjust_customer.h Source.h Hdmi.H HdmiModeTable.H
    ./Lib/: GmiFunc.h VideoDec.H
  group Panel
    ./Panel/: Panel.h PNL_LVDS.h PNL_TTL.h
  group PCB
    ./PCB/: Pcb.h Pcb_RTD3580D_LCDTV_DEMO_PCB1.h
    $TC_ROOT$/../../项目/单工/second/5-RTD2660源码/RTD2660_demo_source/RTD2660_V025_2662-7寸屏高清程序_logo_2_bin/RTD2660_V025_2662-7寸屏高清程序_logo_2/PCB/: Pcb_RTD3580D_LCDTV_DEMO_PCB2.h
  group Key_B0
    ./Keys/: Key.c Key.h CyKey.h Key_PCB2660_001.c Key_PCB2660_001.h Key_PCB2660_002.c Key_PCB2660_002.h Key_PCB2660_003.c Key_PCB2660_003.H Key_PCB2660_003_5Key.c Key_PCB2660_003_5Key.h Key_PCB2660_007.c Key_PCB2660_007.H
    ./Core/code/: IR_Nec.c
    ./Core/header/: IR_Nec.h
  group Func_B0
    ./Func/: Func.C Func.H gmi_Sc7313.c
  group OSD001_B1
    ./OSD/OSD001/: OsdProc001.c OsdProc001.h OsdMenuFunc001.c OsdMenuFunc001.h OsdRes001.c OsdRes001.h OsdTable001.c OsdTable001.h OSDStruct001.h
  group OSD002_B1
    ./OSD/OSD002/: OsdProc002.c OsdProc002.h OsdMenuFunc002.c OsdMenuFunc002.h OsdRes002.c OsdRes002.h OsdTable002.c OsdTable002.h Osd002Func.C Osd002Func.H OSDStruct002.h
  group OSD003_B1
    ./OSD/OSD003/: OsdMenuFunc003.c OsdMenuFunc003.h OsdProc003.c OsdProc003.h OsdRes003.c OsdRes003.h OsdTable003.c OsdTable003.h OSDStruct003.h
    ./Factory/: OSD_FAC.c OSD_FAC.h
  group OSD007_B1
    ./OSD/OSD007/: OsdPub007.c Osdpub007.h OsdVga007.c OsdVga007.h OsdAV007.c OsdAV007.h OsdTV007.c OsdTV007.h Font007.h Osd007.h
  group TV_B0
    ./TV/: TV.c TV.H JS_6B1.C JS_6B1.H JS_6B2.C JS_6B2.H TDQ6F6.C TDQ6F6.H TN8337.C TN8337.H TNJ8355.C TNJ8355.H JS_6AM.C JS_6AM.H FreqTable.C FreqTable.H PHILIPS_MK3.C PHILIPS_MK3.H
  group Lib
    ./Lib/: GmiFunc.LIB WriteDisable.LIB
  group Gmifunc_B1
    ./OSD/: gmiOSDFunc.c gmiOSDFunc.h
    ./Lib/: TB1338.H
  group Code_Common
    ./Misc/: GUartSend.c GUartSend.h
    ./Core/code/mcu/: Int.c Mcu.c RTDAccess.c I2c.c
    ./Core/code/: L51_BANK.A51 STARTUP.A51
  group DDCCI_B0
    ./DDCCI/: DDCCI.h DDCCIDBG.H
